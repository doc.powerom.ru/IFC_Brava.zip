Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Номер проекта
Time: 2022-09-05T10:51:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190225_1515(x64) - Exporter 19.2.10.7 - Альтернативный интерфейс 19.2.10.7
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 05 10:51:54 2022 * Host: Dell * Database: C:\Users\6EDA~1\AppData\Local\Temp\{3DD536E3-A758-48BC-B00F-4C96860F2F31}\ifc * Database version: 5507 * Database creation date: Mon Sep 05 10:51:42 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 05 10:51:42 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 05 10:51:42 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Номер проекта
LongName: Наименование проекта; Phase: П

# IfcSite, Default
RefLatitude: 55, 44, 57, 789001; RefLongitude: 37, 38, 4, 304809; RefElevation: 0 mm

# IfcBuilding, Наименование здания
LongName: Наименование здания
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
In: Наименование здания
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2 модуля, КНС_КаркасыДляМонтажаЭУИBravaВСтеныИКоробкиPDD-N60_DKC:2 модуля:660043
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 2 модуля

# IfcBuildingElementProxy: 2 модуля (3)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2 модуля
Name
КНС_КаркасНа2Модуля(одноместный)БезЛапок_DKC:2 модуля:605950
КНС_КаркасыДляМонтажаЭУИBravaВСтеныИКоробкиPDD-N60_DKC:2 модуля:607951
КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N60_DKC:2 модуля:613597

# IfcBuildingElementProxy: 2 модуля, КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N60_DKC:2 модуля:665539
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля

# IfcBuildingElementProxy: 2 модуля (7)
In: Этаж 01
Type - Material: DKC_Пластик_СерыйМеталлик
Pset_BuildingElementProxyCommon - Reference: 2 модуля
Name (Суппорт для монтажа ЭУИ серии Viva на DIN-рейку или монтажную плату_DKC:2 модуля:...)
602460
673175
673179
673183
673187
673191
673195

# IfcBuildingElementProxy: 2 модуля (2)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 2 модуля
Name
КНС_КаркасыДляМонтажаЭУИBravaВСтеныИКоробкиPDD-N60_DKC:2 модуля:660051
КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N60_DKC:2 модуля:665536

# IfcBuildingElementProxy: 2 модуля, КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N60_DKC:2 модуля:665523
In: Этаж 01
Type - Material: DKC_ПластикКоричневыйPANTONE
Pset_BuildingElementProxyCommon - Reference: 2 модуля

# IfcBuildingElementProxy: 2+2 модуля, КНС_РамкаНа2+2Модуля(двухместная)_DKC:2+2 модуля:611762
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2+2 модуля

# IfcBuildingElementProxy: 2+2 модуля, КНС_РамкаНа2+2Модуля(двухместная)_DKC:2+2 модуля:670548
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2+2 модуля

# IfcBuildingElementProxy: 2+2 модуля, КНС_РамкаНа2+2Модуля(двухместная)_DKC:2+2 модуля:670532
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 2+2 модуля

# IfcBuildingElementProxy: 2х3 модулей, КНС_РамкаНа2x3Модуля(трехместная)_DKC:2х3 модулей:610849
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2х3 модулей

# IfcBuildingElementProxy: 2х3 модулей, КНС_РамкаНа2x3Модуля(трехместная)_DKC:2х3 модулей:670547
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2х3 модулей

# IfcBuildingElementProxy: 2х3 модулей, КНС_РамкаНа2x3Модуля(трехместная)_DKC:2х3 модулей:670531
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 2х3 модулей

# IfcBuildingElementProxy: 2х4 модулей, КНС_РамкаНа2x4Модуля(четырехместная)_DKC:2х4 модулей:609910
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2х4 модулей

# IfcBuildingElementProxy: 2х4 модулей, КНС_РамкаНа2x4Модуля(четырехместная)_DKC:2х4 модулей:670546
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2х4 модулей

# IfcBuildingElementProxy: 2х4 модулей, КНС_РамкаНа2x4Модуля(четырехместная)_DKC:2х4 модулей:670530
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 2х4 модулей

# IfcBuildingElementProxy: 2х5 модулей, КНС_РамкаНа2x5Модуля(пятиместная)_DKC:2х5 модулей:608944
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2х5 модулей

# IfcBuildingElementProxy: 2х5 модулей, КНС_РамкаНа2x5Модуля(пятиместная)_DKC:2х5 модулей:670545
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 2х5 модулей

# IfcBuildingElementProxy: 2х5 модулей, КНС_РамкаНа2x5Модуля(пятиместная)_DKC:2х5 модулей:670529
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 2х5 модулей

# IfcBuildingElementProxy: 4 модуля, КНС_КаркасыДляМонтажаЭУИBravaВКоробкиPDD-N120_DKC:4 модуля:658960
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 4 модуля

# IfcBuildingElementProxy: 4 модуля (2)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 4 модуля
Name
КНС_КаркасыДляМонтажаЭУИBravaВКоробкиPDD-N120_DKC:4 модуля:606922
КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N120_DKC:4 модуля:612695

# IfcBuildingElementProxy: 4 модуля, КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N120_DKC:4 модуля:666532
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: 4 модуля

# IfcBuildingElementProxy: 4 модуля, КНС_РамкаДляМонтажаЭУИBravaВКоробкиPDD-N120_DKC:4 модуля:666521
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: 4 модуля

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:HDMI:604922
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: HDMI (2)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: HDMI
Name (КНС_МультимедийныеРозеткиHDMIиUSB_DKC:HDMI:...)
664473
664482

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:HDMI:664476
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:HDMI:664479
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: HDMI, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:HDMI:664462
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: HDMI

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 2.0:664540
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 2.0 (2)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 2.0
Name (КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 2.0:...)
664542
664545

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 2.0:664543
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 2.0:664544
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 2.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 2.0:664541
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 2.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 3.0:664553
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: USB 3.0 (2)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 3.0
Name (КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 3.0:...)
664555
664558

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 3.0:664556
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 3.0:664557
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: USB 3.0, КНС_МультимедийныеРозеткиHDMIиUSB_DKC:USB 3.0:664554
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: USB 3.0

# IfcBuildingElementProxy: Белый (6)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый
Name
КНС_ЗуммерыИЗвонки_DKC:Белый:594895
КНС_ЭлектрическаяРозетка1Модуль_DKC:Белый:599901
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Белый:602459
КНС_ЗуммерыИЗвонки_DKC:Белый:656793
КНС_ЗуммерыИЗвонки_DKC:Белый:656808
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Белый:673182

# IfcBuildingElementProxy: Белый (21)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый
Name
КНС_ТелефонныеРозетки_DKC:Белый:575171
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:592450
КНС_TVРозетка_DKC:Белый:654247
КНС_TVРозетка_DKC:Белый:654260
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:661760
КНС_ТелефонныеРозетки_DKC:Белый:674961
КНС_ТелефонныеРозетки_DKC:Белый:674976
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714222
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714226
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714249
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714280
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714329
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714330
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714332
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714333
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714343
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714344
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714348
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714358
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714359
КНС_КомпьютерныеРозеткиRJ45_DKC:Белый:714363

# IfcBuildingElementProxy: Белый, КНС_TVРозетка_DKC:Белый:597381
In: Этаж 01
Type - Material: DKC_СтальНержавеющая, DKC_Пластик_Серо-черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый

# IfcBuildingElementProxy: Выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Выключатель
Name (КНС_ВыключателиПереключатели_DKC:Выключатель:...)
590804
680223
680231

# IfcBuildingElementProxy: Выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Выключатель
Name (КНС_ВыключателиПереключатели_DKC:Выключатель:...)
680295
680296
680297

# IfcBuildingElementProxy: Выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Выключатель
Name (КНС_ВыключателиПереключатели_DKC:Выключатель:...)
680269
680270
680271

# IfcBuildingElementProxy: Выключатель типа кнопка (3)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Выключатель типа кнопка
Name (КНС_ВыключателиПереключатели_DKC:Выключатель типа кнопка:...)
680317
680318
680319

# IfcBuildingElementProxy: Выключатель типа кнопка (3)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Выключатель типа кнопка
Name (КНС_ВыключателиПереключатели_DKC:Выключатель типа кнопка:...)
680323
680324
680325

# IfcBuildingElementProxy: Выключатель типа кнопка (3)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Выключатель типа кнопка
Name (КНС_ВыключателиПереключатели_DKC:Выключатель типа кнопка:...)
680320
680321
680322

# IfcBuildingElementProxy: Двухполюсный выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Двухполюсный выключатель
Name (КНС_ВыключателиПереключатели_DKC:Двухполюсный выключатель:...)
680335
680336
680337

# IfcBuildingElementProxy: Двухполюсный выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Двухполюсный выключатель
Name (КНС_ВыключателиПереключатели_DKC:Двухполюсный выключатель:...)
680341
680342
680343

# IfcBuildingElementProxy: Двухполюсный выключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Двухполюсный выключатель
Name (КНС_ВыключателиПереключатели_DKC:Двухполюсный выключатель:...)
680338
680339
680340

# IfcBuildingElementProxy: Заглушки_DKC, КНС_Заглушки_DKC:Заглушки_DKC:682951
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: Заглушки_DKC

# IfcBuildingElementProxy: Заглушки_DKC, КНС_Заглушки_DKC:Заглушки_DKC:616112
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Заглушки_DKC

# IfcBuildingElementProxy: Заглушки_DKC, КНС_Заглушки_DKC:Заглушки_DKC:682943
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Заглушки_DKC

# IfcBuildingElementProxy: Инвертор (промежуточный переключатель), КНС_ВыключателиПереключатели_DKC:Инвертор (промежуточный переключатель):680375
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Инвертор (промежуточный переключатель)

# IfcBuildingElementProxy: Инвертор (промежуточный переключатель), КНС_ВыключателиПереключатели_DKC:Инвертор (промежуточный переключатель):680381
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Инвертор (промежуточный переключатель)

# IfcBuildingElementProxy: Инвертор (промежуточный переключатель), КНС_ВыключателиПереключатели_DKC:Инвертор (промежуточный переключатель):680378
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Инвертор (промежуточный переключатель)

# IfcBuildingElementProxy: Красный, КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Красный:673186
In: Этаж 01
Type - Material: DKC_Пластик_Красный
Pset_BuildingElementProxyCommon - Reference: Красный

# IfcBuildingElementProxy: Лого, Лого:Лого:586985
In: Этаж 01
Type - Material: DKC_КрасныйЛого
Pset_BuildingElementProxyCommon - Reference: Лого

# IfcBuildingElementProxy: Переключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Переключатель
Name (КНС_ВыключателиПереключатели_DKC:Переключатель:...)
680382
680383
680384

# IfcBuildingElementProxy: Переключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Переключатель
Name (КНС_ВыключателиПереключатели_DKC:Переключатель:...)
680388
680389
680390

# IfcBuildingElementProxy: Переключатель (3)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Переключатель
Name (КНС_ВыключателиПереключатели_DKC:Переключатель:...)
680385
680386
680387

# IfcBuildingElementProxy: Слоновая кость (21)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный, DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Слоновая кость
Name
КНС_TVРозетка_DKC:Слоновая кость:654266
КНС_TVРозетка_DKC:Слоновая кость:654269
КНС_ТелефонныеРозетки_DKC:Слоновая кость:675046
КНС_ТелефонныеРозетки_DKC:Слоновая кость:675047
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714485
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714486
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714495
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714496
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714503
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714510
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714525
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714526
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714528
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714529
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714532
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714533
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714537
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714540
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714541
КНС_КомпьютерныеРозеткиRJ45_DKC:Слоновая кость:714545
КНС_ТелефонныеРозетки_DKC:Слоновая кость:717375

# IfcBuildingElementProxy: Слоновая кость (6)
In: Этаж 01
Type - Material: DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Слоновая кость
Name
КНС_ЗуммерыИЗвонки_DKC:Слоновая кость:656811
КНС_ЗуммерыИЗвонки_DKC:Слоновая кость:656814
КНС_ЗуммерыИЗвонки_DKC:Слоновая кость:656817
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Слоновая кость:673174
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Слоновая кость:673190
КНС_ЭлектрическаяРозетка1Модуль_DKC:Слоновая кость:677658

# IfcBuildingElementProxy: Слоновая кость, КНС_TVРозетка_DKC:Слоновая кость:654263
In: Этаж 01
Type - Material: DKC_СтальНержавеющая, DKC_Пластик_Серо-черный, DKC_Пластик_СлоноваяКость
Pset_BuildingElementProxyCommon - Reference: Слоновая кость

# IfcBuildingElementProxy: Текст модели:100 мм Arial (42)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 100 мм Arial

# IfcBuildingElementProxy: Текст модели:150 мм Arial (18)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 150 мм Arial

# IfcBuildingElementProxy: Текст модели:600 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 600 мм Arial

# IfcBuildingElementProxy: Текст модели:80 мм Arial (127)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 80 мм Arial

# IfcBuildingElementProxy: Черный (28)
In: Этаж 01
Type - Material: DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Черный
Name
КНС_TVРозетка_DKC:Черный:654275
КНС_TVРозетка_DKC:Черный:654278
КНС_ЗуммерыИЗвонки_DKC:Черный:656820
КНС_ЗуммерыИЗвонки_DKC:Черный:656823
КНС_ЗуммерыИЗвонки_DKC:Черный:656826
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Черный:673178
КНС_СиловыеЭлектрическиеРозеткиШтекерныеСоШторками_DKC:Черный:673194
КНС_ТелефонныеРозетки_DKC:Черный:675080
КНС_ТелефонныеРозетки_DKC:Черный:675081
КНС_ТелефонныеРозетки_DKC:Черный:675082
КНС_ЭлектрическаяРозетка1Модуль_DKC:Черный:677666
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714604
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714605
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714614
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714615
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714622
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714629
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714644
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714645
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714647
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714648
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714651
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714652
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714656
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714659
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714660
КНС_КомпьютерныеРозеткиRJ45_DKC:Черный:714664
КНС_ТелефонныеРозетки_DKC:Черный:717376

# IfcBuildingElementProxy: Черный, КНС_TVРозетка_DKC:Черный:654272
In: Этаж 01
Type - Material: DKC_СтальНержавеющая, DKC_Пластик_Серо-черный
Pset_BuildingElementProxyCommon - Reference: Черный
